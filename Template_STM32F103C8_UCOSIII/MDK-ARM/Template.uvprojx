# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\BSP;..\BSP\BSP_Drivers;..\BSP\UCOSIII\uC-CPU;..\BSP\UCOSIII\uC-LIB;..\BSP\UCOSIII\uCOS-III;..\BSP\UCOSIII\UCOS_BSP;..\BSP\UCOSIII\UCOS_CONFIG;..\BSP\UCOSIII\uCOS-III\Source;..\BSP\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\BSP\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\BSP\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\BSP\UCOSIII\uCOS_DELAY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: stm32f1xx_it.c gpio.c stm32f1xx_hal_msp.c usart.c main.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group UCOSIII-BSP
    ../BSP/UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../BSP/UCOSIII/uC-CPU/: cpu_core.c
    ../BSP/UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../BSP/UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../BSP/UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../BSP/UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_flag.c os_dbg.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../BSP/UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOSIII-CONFIG
    ../BSP/UCOSIII/UCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOSIII-DELAY
    ../BSP/UCOSIII/uCOS_DELAY/: delay.c
  group BSP
    ../BSP/: BSP_Main.c SYS.c
  group BSP_Drivers
    ../BSP/BSP_Drivers/: BSP_Flash.c
  group README
    ../README/: README.TXT
software components: CMSIS:CORE 4.1.0
